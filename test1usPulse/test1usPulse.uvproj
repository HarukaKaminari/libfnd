# Keil uVision project test1usPulse.uvproj, settings and files
target test1usPulse (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: test1usPulse
  c flags: Optimize=9 SizeSpeed=1
  group source
    ./: main.c
  group linfnd
    ../libfnd/: STC12C5A60S2.h typedef.h Uart.c Uart.h Utility.c Utility.h Timer.c Timer.h
