# Keil uVision project testIST3932.uvproj, settings and files
target testIST3932 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: testIST3932
  c flags: Optimize=8 SizeSpeed=1
  c define: USE_HARDWARE_SPI,LCM_DRIVER_IST3932
  group source
    ./: main.c
  group libfnd
    ../libfnd/: IST3932.c IST3932.h LCM12864.c LCM12864.h SPI.c SPI.h STC12C5A60S2.h typedef.h Utility.c Utility.h FontText.h
