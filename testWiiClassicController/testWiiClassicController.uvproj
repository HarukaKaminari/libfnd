# Keil uVision project testWiiClassicController.uvproj, settings and files
target testWiiClassicController (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: testWiiClassicController
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: main.c
  group libfnd
    ../libfnd/: I2C.c I2C.h STC12C5A60S2.h typedef.h Uart.c Uart.h Utility.c Utility.h WiiClassicController.c WiiClassicController.h
